# Keil uVision project Quadrotor.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: Quadrotor
  c flags: Optim=1
  c define: __heap_base__=Image$$RW_IRAM1$$ZI$$Limit __heap_end__=Image$$RW_IRAM2$$Base
  c include: ..\Git_Quadrotor;.\os\kernel\include;.\os\ports\common\ARMCMx;.\os\ports\common\ARMCMx\CMSIS\include;.\os\ports\RVCT\ARMCMx;.\os\ports\RVCT\ARMCMx\STM32L1xx;.\os\hal\include;.\os\hal\platforms;.\os\hal\platforms\STM32;.\os\hal\platforms\STM32\GPIOv2;.\os\hal\platforms\STM32\USARTv1;.\os\hal\platforms\STM32L1xx;.\conf;.\os\hal\platforms\STM32\I2Cv1
  asm misc: --cpreproc
  asm include: ..\Git_Quadrotor;.\conf;.\os\ports\RVCT\ARMCMx\STM32L1xx
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20020000 size 0x1
  group main
    ./conf/: main.c XBee.c gyro.c compass.c alti.c
  group conf
    ./conf/: board.c board.h chconf.h halconf.h mcuconf.h
  group os
    ./os/kernel/src/: chlists.c chschd.c chthreads.c chsys.c chvt.c chsem.c chdebug.c chcond.c chdynamic.c chevents.c chheap.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c
  group hal
    ./os/hal/src/: hal.c pal.c tm.c serial.c i2c.c
  group platform
    ./os/hal/platforms/STM32L1xx/: hal_lld.c stm32_dma.c
    ./os/hal/platforms/STM32/GPIOv2/: pal_lld.c
    ./os/hal/platforms/STM32/USARTv1/: serial_lld.c
    ./os/hal/platforms/STM32/I2Cv1/: i2c_lld.c
  group port
    ./os/ports/RVCT/ARMCMx/: chcore_v7m.c chcore.c cstartup.s chcoreasm_v7m.s
    ./os/ports/common/ARMCMx/: nvic.c
    ./os/ports/RVCT/ARMCMx/STM32L1xx/: vectors.s
